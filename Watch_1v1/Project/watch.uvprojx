# Keil uVision project watch.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: watch +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE
  c include: ..\CMSIS;..\User\inc;..\User\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.h
  group User
    ./: README.txt
    ../User/src/: main.c led.c systick.c exti.c motor.c key.c tim3_ch2_pwm.c tim2_ch3_pwm .c spi.c oled.c iic.c sht20.c hp_6.c rtc.c stepAlgorithm.c watchInfo.c mpu_iic.c mpu6050.c ui.c
